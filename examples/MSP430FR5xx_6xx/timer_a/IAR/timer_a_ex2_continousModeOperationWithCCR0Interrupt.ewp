# IAR project timer_a_ex2_continousModeOperationWithCCR0Interrupt.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5969 MSP430FR5969
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\..\driverlib\MSP430FR5xx_6xx
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FR5969.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../: timer_a_ex2_continousModeOperationWithCCR0Interrupt.c
  group driverlib/MSP430FR5xx_6xx
    ../../../../driverlib/MSP430FR5xx_6xx/: adc12_b.c adc12_b.h aes256.c aes256.h comp_e.c comp_e.h crc.c crc.h crc32.c crc32.h cs.c cs.h dma.c dma.h driverlib.h esi.c esi.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h fram.c fram.h gpio.c gpio.h lcd_c.c lcd_c.h mpu.c mpu.h mpy32.c mpy32.h pmm.c pmm.h ram.c ram.h ref_a.c ref_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h sfr.c sfr.h sys.c sys.h timer_a.c timer_a.h timer_b.c timer_b.h tlv.c tlv.h wdt_a.c wdt_a.h
  group driverlib/MSP430FR5xx_6xx/deprecated
    ../../../../driverlib/MSP430FR5xx_6xx/deprecated/: cs.c cs.h dma.c dma.h fram.c fram.h mpy32.c mpy32.h pmm.c pmm.h sfr.c sfr.h sys.c sys.h
  group driverlib/MSP430FR5xx_6xx/deprecated/IAR
    ../../../../driverlib/MSP430FR5xx_6xx/deprecated/IAR/: msp430fr5xx_6xxgeneric.h
  group driverlib/MSP430FR5xx_6xx/inc
    ../../../../driverlib/MSP430FR5xx_6xx/inc/: hw_memmap.h hw_regaccess.h hw_types.h version.h
