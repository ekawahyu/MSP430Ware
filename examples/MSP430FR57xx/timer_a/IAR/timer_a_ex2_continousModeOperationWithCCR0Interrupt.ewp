# IAR project timer_a_ex2_continousModeOperationWithCCR0Interrupt.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\..\driverlib\MSP430FR57xx
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  group (top)
    ../: timer_a_ex2_continousModeOperationWithCCR0Interrupt.c
  group driverlib/MSP430FR57xx
    ../../../../driverlib/MSP430FR57xx/: adc10_b.c adc10_b.h comp_d.c comp_d.h crc.c crc.h cs.c cs.h dma.c dma.h driverlib.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h eusci_i2c.c eusci_i2c.h eusci_spi.c eusci_spi.h eusci_uart.c eusci_uart.h fram.c fram.h gpio.c gpio.h mpu.c mpu.h mpy32.c mpy32.h pmm.c pmm.h ref.c ref.h rtc_b.c rtc_b.h sfr.c sfr.h sys.c sys.h timer_a.c timer_a.h timer_b.c timer_b.h tlv.c tlv.h wdt_a.c wdt_a.h
  group driverlib/MSP430FR57xx/deprecated
    ../../../../driverlib/MSP430FR57xx/deprecated/: cs.c cs.h dma.c dma.h fram.c fram.h mpy32.c mpy32.h pmm.c pmm.h sfr.c sfr.h sys.c sys.h
  group driverlib/MSP430FR57xx/deprecated/IAR
    ../../../../driverlib/MSP430FR57xx/deprecated/IAR/: msp430fr57xxgeneric.h
  group driverlib/MSP430FR57xx/inc
    ../../../../driverlib/MSP430FR57xx/inc/: hw_memmap.h hw_regaccess.h hw_types.h version.h
