# IAR project sd24_ex6_singleConversionSingleConversionTempSensor.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430i2041 MSP430i2041
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\..\driverlib\MSP430i2xx
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FR5969.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../: sd24_ex6_singleConversionSingleConversionTempSensor.c
  group driverlib/MSP430i2xx
    ../../../../driverlib/MSP430i2xx/: cs.c cs.h driverlib.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h flash.c flash.h gpio.c gpio.h mpy.c mpy.h pmm.c pmm.h sd24.c sd24.h sfr.c sfr.h timer_a.c timer_a.h tlv.c tlv.h wdt.c wdt.h
  group driverlib/MSP430i2xx/deprecated/GCC
    ../../../../driverlib/MSP430i2xx/deprecated/GCC/: msp430i2020.h msp430i2021.h msp430i2030.h msp430i2031.h msp430i2040.h msp430i2041.h msp430i2xxgeneric.h
  group driverlib/MSP430i2xx/deprecated/IAR
    ../../../../driverlib/MSP430i2xx/deprecated/IAR/: msp430i2020.h msp430i2021.h msp430i2030.h msp430i2031.h msp430i2040.h msp430i2041.h msp430i2xxgeneric.h
  group driverlib/MSP430i2xx/inc
    ../../../../driverlib/MSP430i2xx/inc/: hw_memmap.h hw_regaccess.h version.h
