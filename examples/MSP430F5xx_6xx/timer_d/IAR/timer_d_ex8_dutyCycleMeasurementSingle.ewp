# IAR project timer_d_ex8_dutyCycleMeasurementSingle.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5172 MSP430F5172
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\..\driverlib\MSP430F5xx_6xx
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  group (top)
    ../: timer_d_ex8_dutyCycleMeasurementSingle.c
  group driverlib/MSP430F5xx_6xx
    ../../../../driverlib/MSP430F5xx_6xx/: adc10_a.c adc10_a.h adc12_a.c adc12_a.h aes.c aes.h bak_batt.c bak_batt.h comp_b.c comp_b.h crc.c crc.h dac12_a.c dac12_a.h dma.c dma.h driverlib.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h eusci_i2c.c eusci_i2c.h eusci_spi.c eusci_spi.h eusci_uart.c eusci_uart.h flash.c flash.h gpio.c gpio.h ldopwr.c ldopwr.h mpy32.c mpy32.h pmap.c pmap.h pmm.c pmm.h ram.c ram.h ref.c ref.h rtc_a.c rtc_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h sd24_b.c sd24_b.h sfr.c sfr.h sys.c sys.h tec.c tec.h timer_a.c timer_a.h timer_b.c timer_b.h timer_d.c timer_d.h tlv.c tlv.h ucs.c ucs.h usci_a_spi.c usci_a_spi.h usci_a_uart.c usci_a_uart.h usci_b_i2c.c usci_b_i2c.h usci_b_spi.c usci_b_spi.h usci_i2c.c usci_i2c.h usci_spi.c usci_spi.h usci_uart.c usci_uart.h wdt_a.c wdt_a.h
  group driverlib/MSP430F5xx_6xx/deprecated
    ../../../../driverlib/MSP430F5xx_6xx/deprecated/: dma.c dma.h flash.c flash.h mpy32.c mpy32.h pmm.c pmm.h ram.c ram.h sfr.c sfr.h sys.c sys.h ucs.c ucs.h
  group driverlib/MSP430F5xx_6xx/deprecated/IAR
    ../../../../driverlib/MSP430F5xx_6xx/deprecated/IAR/: msp430f5xx_6xxgeneric.h
  group driverlib/MSP430F5xx_6xx/inc
    ../../../../driverlib/MSP430F5xx_6xx/inc/: hw_memmap.h hw_regaccess.h hw_types.h version.h
